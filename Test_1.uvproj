# Keil uVision project Test_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Test_1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: test2.a51
